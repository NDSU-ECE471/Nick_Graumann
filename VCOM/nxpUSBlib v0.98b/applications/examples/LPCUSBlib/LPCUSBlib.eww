<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\libraries\BSP\BSP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\libraries\CDL\CDL.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_AudioInputDevice\Example_AudioInputDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_AudioOutputDevice\Example_AudioOutputDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_AudioOutputHost\Example_AudioOutputHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_GenericHIDDevice\Example_GenericHIDDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_KeyboardDevice\Example_KeyboardDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_KeyboardHost\Example_KeyboardHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_KeyboardHostDevice\Example_KeyboardHostDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_MassStorageDevice\Example_MassStorageDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_MassStorageHost\Example_MassStorageHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_MouseDevice\Example_MouseDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Example_VirtualSerial\Example_VirtualSerialDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\libraries\LPCUSBlib\LPCUSBlib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Example_AudioInputDevice_LPC4350_HITEX_A4_IRAM</name>
      <member>
        <project>BSP</project>
        <configuration>LPC4350_HITEX_A4</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>Example_AudioInputDevice</project>
        <configuration>HITEX_LPC4350_M4_IRAM</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_MCB1000</name>
      <member>
        <project>BSP</project>
        <configuration>LPC11u14_MCB1000</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC11Uxx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC11Uxx_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>MCB1000</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_MCB1000</name>
      <member>
        <project>BSP</project>
        <configuration>LPC11u14_MCB1000</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC11Uxx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC11Uxx_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>MCB1000</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_MCB1700</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1768_MCB1700</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC17xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC17xx_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>MCB1700</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_MCB1700</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1768_MCB1700</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC17xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC17xx_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>MCB1700</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC1788_EAOEMBaseRevA</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1788_EAOEMBaseRevA</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC177x_8x</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC177x_8x_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>LPC1788_EAOEMBaseRevA</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC1788_EAOEMBaseRevA</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1788_EAOEMBaseRevA</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC177x_8x</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC177x_8x_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>LPC1788_EAOEMBaseRevA</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC1830_XPLORER</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1830_XPLORER</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC18xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>Xplorer1830</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC1830_XPLORER</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1830_XPLORER</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC18xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>Xplorer1830</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC1850_HITEX_A4</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1850_HITEX_A4</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC18xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>LPC1850_HITEX_A4</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC1850_HITEX_A4</name>
      <member>
        <project>BSP</project>
        <configuration>LPC1850_HITEX_A4</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC18xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>LPC1850_HITEX_A4</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC1850_MCB1800</name>
      <member>
        <project>CDL</project>
        <configuration>LPC18xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>BSP</project>
        <configuration>LPC1857_MCB1800</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>LPC1857_MCB1800</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC1850_MCB1800</name>
      <member>
        <project>CDL</project>
        <configuration>LPC18xx</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>BSP</project>
        <configuration>LPC1857_MCB1800</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>LPC1857_MCB1800</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC4350_HITEX_A4_IRAM</name>
      <member>
        <project>BSP</project>
        <configuration>LPC4350_HITEX_A4</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>HITEX_LPC4350_M4_IRAM</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC4350_HITEX_A4_IRAM</name>
      <member>
        <project>BSP</project>
        <configuration>LPC4350_HITEX_A4</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>HITEX_LPC4350_M4_IRAM</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC4330_Xplorer</name>
      <member>
        <project>BSP</project>
        <configuration>LPC4330_Xplorer</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>Xplorer4330</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC4330_Xplorer</name>
      <member>
        <project>BSP</project>
        <configuration>LPC4330_Xplorer</configuration>
      </member>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>Xplorer4330</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>MassStorageDevice_LPC4350_MCB4300</name>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>BSP</project>
        <configuration>LPC4357_MCB4300</configuration>
      </member>
      <member>
        <project>Example_MassStorageDevice</project>
        <configuration>LPC4357_MCB4300</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>VirtualSerialDevice_LPC4350_MCB4300</name>
      <member>
        <project>CDL</project>
        <configuration>LPC43xx_M4</configuration>
      </member>
      <member>
        <project>LPCUSBlib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>BSP</project>
        <configuration>LPC4357_MCB4300</configuration>
      </member>
      <member>
        <project>Example_VirtualSerialDevice</project>
        <configuration>LPC4357_MCB4300</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


