# Keil uVision project CDL.uvproj, settings and files
target LPC11Uxx (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CDL_LPC11Uxx (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC11UXX__
  c include: CMSISv2p00_LPC11Uxx/inc;CMSISv2p00_LPC11Uxx/lpcinc;LPC11UxxLib/inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Core
    ./CMSISv2p00_LPC17xx/src/: core_cm3.c
    ./CMSISv2p00_LPC11Uxx/src/: core_cm0.c
    ./CMSISv2p00_LPC43xx/src/: core_cm4.c
  group LPC11Uxx
    ./LPC11UxxLib/src/: lpc11uxx_gpio.c lpc11uxx_i2c.c lpc11uxx_pinsel.c
    ./CMSISv2p00_LPC11Uxx/src/: system_LPC11Uxx.c startup_LPC11Uxx.s
  group LPC177x_8x
    ./CMSISv2p00_LPC177x_8x/src/: system_LPC177x_8x.c startup_LPC177x_8x.s
    ./LPC177x_8xLib/src/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_bod.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_iap.c lpc177x_8x_lcd.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
  group LPC17xx
    ./LPC17xxLib/src/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c lpc17xx_debug_frmwrk.c
    ./CMSISv2p00_LPC17xx/src/: startup_LPC17xx.s system_LPC17xx.c
  group LPC18xx
    ./LPC18xxLib/src/: lpc18xx_adc.c lpc18xx_atimer.c lpc18xx_can.c lpc18xx_cgu.c lpc18xx_dac.c lpc18xx_evrt.c lpc18xx_gpdma.c lpc18xx_gpio.c lpc18xx_i2c.c lpc18xx_i2s.c lpc18xx_lcd.c lpc18xx_mcpwm.c lpc18xx_nvic.c lpc18xx_pwr.c lpc18xx_qei.c lpc18xx_rgu.c lpc18xx_rit.c lpc18xx_rtc.c lpc18xx_sct.c lpc18xx_scu.c lpc18xx_ssp.c lpc18xx_timer.c lpc18xx_uart.c lpc18xx_wwdt.c LPC18xx_debug_frmwrk.c lpc18xx_emc.c
    ./CMSISv2p00_LPC18xx/src/: system_LPC18xx.c startup_LPC18xx.s
    ./LPC18xxLib/lib/: spifi_drv_M3.lib
  group LPC43xx
    ./LPC43xxLib/src/: Font5x7.c LCDTerm.c lpc43xx_adc.c lpc43xx_atimer.c lpc43xx_can.c lpc43xx_cgu.c lpc43xx_dac.c lpc43xx_emc.c lpc43xx_evrt.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_i2s.c lpc43xx_lcd.c lpc43xx_mcpwm.c lpc43xx_nvic.c lpc43xx_pwr.c lpc43xx_qei.c lpc43xx_rgu.c lpc43xx_rit.c lpc43xx_rtc.c lpc43xx_sct.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c lpc43xx_wwdt.c sdio.c
    ./CMSISv2p00_LPC43xx/src/: fpu_enable.c fpu_init.c system_LPC43xx.c startup_LPC43xx.s
    ./LPC43xxLib/lib/: spifi_drv_M4.lib
target LPC177x_8x (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CDL_LPC177x_8x (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC177X_8X__
  c include: .\CMSISv2p00_LPC177x_8x\inc;.\LPC177x_8xLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CDL_LPC17xx (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__
  c include: CMSISv2p00_LPC17xx/inc;CMSISv2p00_LPC17xx/lpcinc;LPC17xxLib/inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC18xx (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CDL_LPC18xx (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__
  c include: CMSISv2p00_LPC18xx/inc;LPC18xxLib/inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: CDL_LPC43xx (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__
  c include: .\CMSISv2p00_LPC43xx\inc;.\CMSISv2p00_LPC43xx\lpcinc;.\LPC43xxLib\inc
  asm define: NO_CRP
